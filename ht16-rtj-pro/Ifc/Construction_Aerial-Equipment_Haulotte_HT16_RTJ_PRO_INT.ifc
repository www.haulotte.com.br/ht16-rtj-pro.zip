Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-10-13T08:34:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 13 08:34:52 2021 * Host: DESKTOP-0BIHJ9F * Database: C:\Users\BIMOBJ~1\AppData\Local\Temp\{C13E31D1-E6DF-4844-83DE-E712C54EFC3C}\ifc * Database version: 5507 * Database creation date: Wed Oct 13 08:34:51 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 13 08:34:51 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 13 08:34:51 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: HT16 RTJ PRO, Construction_Aerial-Equipment_Haulotte_HT16_RTJ_PRO_INT:HT16 RTJ PRO:215748
In: Level 1
Type - Material: Haulotte - Metal - Black RAL 9017, Haulotte - Metal - Grey RAL 7016, Haulotte - Metal - Yellow RAL 1006, Haulotte - Metal - White
Type - Data - Articulating Jib: 2.94 m / 115,87 in; Drive Speed: micro 0,7 - macro 5.2 km/h /3.23 mph; Energy: 1x12V - 110Ah; Gradeability: 45%; Ground Clearance: 0.24 m/ 9.45 in; Height - Storage / Transport: 3.1 m/ 122.5 in; Height - Stowed: 2.47 m/ 97.46 in; Horizontal Outreach: 13 m/ 42 ft 8 in; Jib Length: 1.80m/ 70.86 in; Lenght - Storage/Transport: 6.68 m/ 262.99 in; Length - Stowed: 9.16 m/ 360.83 in; Lift Capacity: 250 kg (option : restricted 350 kg)/ 771.62 lb; Machine Weight: 7780 kg/ 17151.96 lb; Max Ground Pressure of Wheel on Paved Ground: 15.27 daN/cm²; Platform Height: 14.1 m/ 555 in; Platform Rotation: +90° / -90°; Platform Size: 2.4 x 0.915 m / 96.06 x 36.02 in; Tailswing: 0.94 m/ 36.77 in; Tilt: 5°; Tires: 850 x 340 mm /33.46 x 13.39 in; Turnable Rotation: 360°; Turning Radius - Inside: 1.5 m/ 59.06 in; Turning Radius - Outside: 3.6 m/ 141.73 in; Up and Over Clearance: 2.4 m/ 94.53 in; Vertical Jib Rotation Angle: 68° / -65°; Wheelbase: 2.35 m/ 92.52 in; Width: 2.44 m/ 96.06 in; Working Height: 16.1 m/ 633.74 in
Type - General - Design country: France; Edition number: 1; Manufacturer name: Haulotte; Product name: HT16 RTJ PRO; Product SKU: ht16-rtj-pro
Type - Identity Data - Description: Articulating & telescopic boom all-terrain diesel; Manufacturer: Haulotte; Model: HT16 RTJ PRO; OmniClass Number: 23.23.13.11.19; OmniClass Title: Platform Lifts; Product data url: https://bimobject.com/haulotte/product/ht16-rtj-pro; Product url: https://www.haulotte.co.uk/product/ht16-rtj-pro; Type Name: HT16 RTJ PRO; URL: https://www.haulotte.co.uk/product/ht16-rtj-pro
Type - Materials and Finishes - Main material: Haulotte - Metal - Yellow RAL 1006; Material main: Steel; Secondary material: Haulotte - Metal - Grey RAL 7016; Wheel material: Haulotte - Metal - Black RAL 9017
Type - Other - Category: Specialty Equipment; Family Name: Construction_Aerial-Equipment_Haulotte_HT16_RTJ_PRO_INT
Pset_BuildingElementProxyCommon - Reference: HT16 RTJ PRO
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Construction - Boom Rotation Angle: 76.5 deg; Platform Rotation Angle: 0 deg; Reach Diagram: no; Telescopic Extend: 10620 mm; Turnable Rotation: 0 deg; Turning Radius: no; Vertical Jib Rotation Angle: 68 deg; Working Area: no
Dimensions - Area: 94.712 m2; Volume: 17.1148 m3
Graphics - Branding: yes
Other - Family: Construction_Aerial-Equipment_Haulotte_HT16_RTJ_PRO_INT: HT16 RTJ PRO; Family and Type: Construction_Aerial-Equipment_Haulotte_HT16_RTJ_PRO_INT: HT16 RTJ PRO; Type: Construction_Aerial-Equipment_Haulotte_HT16_RTJ_PRO_INT: HT16 RTJ PRO; Type Id: Construction_Aerial-Equipment_Haulotte_HT16_RTJ_PRO_INT: HT16 RTJ PRO
Phasing - Phase Created: New Construction
