Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-10-13T08:33:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 13 08:33:18 2021 * Host: DESKTOP-0BIHJ9F * Database: C:\Users\BIMOBJ~1\AppData\Local\Temp\{373BF727-72FB-48C6-93B8-2D1B516AE6DF}\ifc * Database version: 5507 * Database creation date: Wed Oct 13 08:33:16 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 13 08:33:16 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 13 08:33:16 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: HT16 RTJ PRO, Construction_Aerial-Equipment_Haulotte_HT16_RTJ_PRO_FR:HT16 RTJ PRO:215775
In: Level 1
Type - Material: Haulotte - Metal - Black RAL 9017, Haulotte - Metal - Grey RAL 7016, Haulotte - Metal - Yellow RAL 1006, Haulotte - Metal - White
Type - Data - Angle de Levage Pendulaire: 68° / -65°; Angle de Rotation Plateforme: +90° / -90°; Angle de Rotation Tourelle: 360°; Capacité Maximum: 250 kg (option : restricted 350 kg)/ 771.62 lb; Déport Arrière: 0.94 m/ 36.77 in; Déport Maximum: 13 m/ 42 ft 8 in; Devers: 5°; Dimensions Plateforme: 2.4 x 0.915 m / 96.06 x 36.02 in; Empattement: 2.35 m/ 92.52 in; Energie: 1x12V - 110Ah; Garde au Sol: 0.24 m/ 9.45 in; Hauteur de Transport: 3.1 m/ 122.5 in; Hauteur Plateforme: 14.1 m/ 555 in; Hauteur Repliée: 2.47 m/ 97.46 in; Hauteur Travail: 16.1 m/ 633.74 in; Largeur Hors Tout: 2.44 m/ 96.06 in; Longueur de Transport: 6.68 m/ 262.99 in; Longueur Hors Tout: 9.16 m/ 360.83 in; Longueur Pendulaire: 1.80m/ 70.86 in; Masse Machine (CE): 7780 kg/ 17151.96 lb; Pente Maximum: 45%; Pneus: 850 x 340 mm /33.46 x 13.39 in; Point D'articulation: 2.94 m / 115,87 in; Pression Max au Sol: 15.27 daN/cm²; Rayon de Braquage Exterieur: 3.6 m/ 141.73 in; Rayon de Braquage Interieur: 1.5 m/ 59.06 in; Up and Over Clearance: 2.4 m/ 94.53 in; Vitesse de Translation: micro 0,7 - macro 5.2 km/h /3.23 mph
Type - General - Design country: France; Edition number: 1; Manufacturer name: Haulotte; Product name: HT16 RTJ PRO; Product SKU: ht16-rtj-pro
Type - Identity Data - Description: Articulating & telescopic boom all-terrain diesel; Manufacturer: Haulotte; Model: HT16 RTJ PRO; OmniClass Number: 23.23.13.11.19; OmniClass Title: Platform Lifts; Product data url: https://bimobject.com/haulotte/product/ht16-rtj-pro; Product url: https://www.haulotte.co.uk/product/ht16-rtj-pro; Type Name: HT16 RTJ PRO; URL: https://www.haulotte.co.uk/product/ht16-rtj-pro
Type - Materials and Finishes - Main material: Haulotte - Metal - Yellow RAL 1006; Material main: Steel; Secondary material: Haulotte - Metal - Grey RAL 7016; Wheel material: Haulotte - Metal - Black RAL 9017
Type - Other - Category: Specialty Equipment; Family Name: Construction_Aerial-Equipment_Haulotte_HT16_RTJ_PRO_FR
Pset_BuildingElementProxyCommon - Reference: HT16 RTJ PRO
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Construction - Abaque de Travail: no; Angle de Levage Flèche: 76.5 deg; Angle de Levage Pendulaire: 68 deg; Angle de Rotation Tourelle: 0 deg; Rayon de Braquage Exterieur: no; Rotation Panier: 0 deg; Sortie du Telescope: 10620 mm; Zone de Travail: no
Dimensions - Area: 94.712 m2; Volume: 17.1148 m3
Graphics - Marque: yes
Other - Family: Construction_Aerial-Equipment_Haulotte_HT16_RTJ_PRO_FR: HT16 RTJ PRO; Family and Type: Construction_Aerial-Equipment_Haulotte_HT16_RTJ_PRO_FR: HT16 RTJ PRO; Type: Construction_Aerial-Equipment_Haulotte_HT16_RTJ_PRO_FR: HT16 RTJ PRO; Type Id: Construction_Aerial-Equipment_Haulotte_HT16_RTJ_PRO_FR: HT16 RTJ PRO
Phasing - Phase Created: New Construction
